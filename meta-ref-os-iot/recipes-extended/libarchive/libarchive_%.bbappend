FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-CVE-2017-5601.patch \
	    file://0001-CVE-2016-10349-CVE-2016-10350.patch"
