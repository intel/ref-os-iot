SRC_URI_remove := "file://ppp-fix-building-with-linux-4.8.patch"
