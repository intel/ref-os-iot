SUMMARY = "OpenCL for REF OS IOT"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    beignet \
    beignet-dev \
"
