FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI += "file://0001-tests-increase-test-coverage-with-error-negative-tes.patch"
