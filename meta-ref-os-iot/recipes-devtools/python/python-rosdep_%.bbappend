FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-disable-testing-do_compile-fails-because-proxy-isn-t.patch"

