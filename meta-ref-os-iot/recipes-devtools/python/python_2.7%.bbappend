FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"
SRC_URI_append = "file://0001-Don-t-use-getentropy-on-Linux.patch"
