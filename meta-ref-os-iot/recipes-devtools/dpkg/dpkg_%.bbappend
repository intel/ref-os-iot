
FILESEXTRAPATHS_prepend := "${THISDIR}/:"

SRC_URI += "file://0001-build-Detect-the-required-GNU-patch.patch"
