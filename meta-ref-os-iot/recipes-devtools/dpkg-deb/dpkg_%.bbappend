FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI_append_class-native = " file://dpkg_use_multithread_xz.patch"
