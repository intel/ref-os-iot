
# Forward to version 1.12.0:
PV = "1.12.0"
SRC_URI[md5sum] = "eaf9505c7acb9b96215cb0ff775d278d"
SRC_URI[sha256sum] = "acee8c8a88b995fb95601b7b43bf0c83f502d9026bca5705f9c0dc44a757997e"
