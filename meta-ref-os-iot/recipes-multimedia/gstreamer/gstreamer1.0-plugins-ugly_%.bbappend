
# Forward to version 1.11.1:
PV = "1.11.1"
SRC_URI[md5sum] = "0234dcf06a403691001b061346d15b7e"
SRC_URI[sha256sum] = "2b8923a5370dacdfbae78edc755d2489577f1240f9881f3bf4efadff75825251"
