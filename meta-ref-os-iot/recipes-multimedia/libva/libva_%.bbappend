SRC_URI = "git://github.com/01org/libva.git;protocol=http"
# 1.8.1 release tag
SRCREV = "ce636b04cb674419f566e688d5e6816e600825df"
