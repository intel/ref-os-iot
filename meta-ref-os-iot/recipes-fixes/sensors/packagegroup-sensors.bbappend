RDEPENDS_${PN} += " \
    upm-dev \
"
