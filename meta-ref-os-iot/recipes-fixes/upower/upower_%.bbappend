DESCRIPTION = "UPower is an abstraction for enumerating power devices, listening to device events and querying history and statistics. "
RRECOMMENDS_${PN}_remove += "pm-utils"
