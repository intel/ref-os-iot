# fix qa step errors

INSANE_SKIP_${PN} = "ldflags"
