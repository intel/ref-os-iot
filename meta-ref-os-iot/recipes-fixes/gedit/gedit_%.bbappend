EXTRA_OECONF += "--disable-spell "
