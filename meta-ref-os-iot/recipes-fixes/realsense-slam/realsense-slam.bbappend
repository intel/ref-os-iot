# overwrite the hashes, they seem to have changed at some point
SRC_URI[md5sum] = "1cd7c8e098bbe9de495c35e414848764"
SRC_URI[sha256sum] = "04c265649d2fea6e09dc02f3e1f18bb9abe01634a10fd7e19c1605f4df2fe809"
