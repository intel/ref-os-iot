# overwrite the hashes, they seem to have changed at some point
SRC_URI[md5sum] = "35278bffc967ca888d5d4172181da28b"
SRC_URI[sha256sum] = "2140f401ec8d0a7b882c30fc95d7ed3bed532165e655957cbab256cc7ba08676"
