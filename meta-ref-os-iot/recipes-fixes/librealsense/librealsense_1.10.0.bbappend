# fix qa step errors

INSANE_SKIP_${PN} = "ldflags"
INSANE_SKIP_${PN}-examples = "ldflags"
INSANE_SKIP_${PN}-graphical-examples = "ldflags"
INSANE_SKIP_${PN}-tests = "ldflags"
