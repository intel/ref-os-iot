FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://CVE-2017-7186.patch"
