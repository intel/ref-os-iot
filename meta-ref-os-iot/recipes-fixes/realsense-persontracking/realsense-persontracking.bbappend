# overwrite the hashes, they seem to have changed at some point
SRC_URI[md5sum] = "3b4b5720701a01be3234fccff49e7e57"
SRC_URI[sha256sum] = "315c41cbea8609aca713dde70f0628e305e34c409fd160bc47f069603ea341e8"
