SRC_URI_remove = "file://0001-opencv-link-dynamically-against-OpenCL-library.patch"
