FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://files/0001-Camera-Adapter-Add-support-for-up-to-four-cameras.patch"

