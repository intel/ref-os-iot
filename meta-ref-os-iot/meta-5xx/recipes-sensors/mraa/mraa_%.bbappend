FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-mraa-Fix-issues-with-gpio-mapping.patch"
