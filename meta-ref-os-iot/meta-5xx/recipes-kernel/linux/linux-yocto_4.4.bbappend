require ${PN}_intel5xx.inc

LINUX_VERSION_INTEL_COMMON = "4.4.41"
SRCREV_machine_corei7-64-intel-common = "a249f6388ace2a4035220c2333649b42c300faa9"
