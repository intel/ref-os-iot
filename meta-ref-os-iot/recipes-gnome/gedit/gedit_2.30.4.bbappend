do_configure_prepend() {
export LIBS="-lgmodule-2.0 -lICE"
}
