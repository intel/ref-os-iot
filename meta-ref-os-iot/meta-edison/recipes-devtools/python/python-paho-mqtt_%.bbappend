# Added for ref-os-iot compilation
TARGET_CC_ARCH += "${LDFLAGS}"

