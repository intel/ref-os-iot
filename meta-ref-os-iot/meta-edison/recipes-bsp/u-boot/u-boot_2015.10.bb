require u-boot.inc
require u-boot-internal.inc
require u-boot-target-env.inc
require u-boot-osip.inc

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=0507cd7da8e7ad6d6701926ec9b84c95"

PR = "r6"
