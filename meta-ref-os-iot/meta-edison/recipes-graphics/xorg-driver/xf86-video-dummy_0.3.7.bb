require ../../../../intel-iot-refkit/openembedded-core/meta/recipes-graphics/xorg-driver/xorg-driver-video.inc

SUMMARY = "X.Org X server -- dummy display driver"
DESCRIPTION = "Dummy Xorg driver for systems without a frame buffer. This is a non-accelerated driver."

LIC_FILES_CHKSUM = "file://COPYING;md5=e7c3fa0724495de18f9c87cc8c4a1e90"

SRC_URI[md5sum] = "071e408461f2fec1764723474fbafdf4"
SRC_URI[sha256sum] = "56f84fcbc515685529ad8e10bca1072731d9c096b97c5d35ddc95cd589b98680"
