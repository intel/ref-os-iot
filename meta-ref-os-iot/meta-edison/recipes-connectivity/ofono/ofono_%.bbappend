RRECOMMENDS_${PN}_remove = "mobile-broadband-provider-info"
DEPENDS_remove = "mobile-broadband-provider-info"
EXTRA_OECONF_append = " --enable-provision=no"

